SUMMARY = "Alexa Automotive Core - CoAssistant Module"
HOMEPAGE = "http://github.com/alexa"
LICENSE = "CLOSED"

DEPENDS = "avs-device-sdk aac-module-core aac-module-alexa"

inherit aac-module devlibsonly