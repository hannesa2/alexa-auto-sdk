FILESEXTRAPATHS_prepend := "${THISDIR}/${P}:"

# Alexa Auto modifications
SRC_URI += "file://0001-AVS-Device-SDK-1.17-patch-for-Co-Assistant-module.patch"
