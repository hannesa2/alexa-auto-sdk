SUMMARY = "Alexa Automotive Core - Address Book Local Module"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://engine/include/AACE/Engine/AddressBookLocalService/AddressBookLocalService.h;beginline=2;endline=13;md5=f5a0c55dc26282d9074749804fb96471"

DEPENDS = "aac-module-core aac-module-address-book aac-module-local-skill-service"

inherit aac-module devlibsonly
