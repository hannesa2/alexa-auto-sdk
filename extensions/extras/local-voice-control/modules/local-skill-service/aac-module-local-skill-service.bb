SUMMARY = "Alexa Automotive Core - Local Skill Service Module"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://platform/include/AACE/LocalSkillService/LocalSkillServiceConfiguration.h;beginline=2;endline=13;md5=9131d55c886a4bdd79557272347ca6f6"

DEPENDS = "aac-module-core curl avs-device-sdk"

inherit aac-module devlibsonly