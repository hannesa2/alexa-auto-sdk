SUMMARY = "Alexa Auto SDK - Car Control Local Service Module"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://engine/include/AACE/Engine/CarControlLocalService/CarControlLocalService.h;beginline=2;endline=13;md5=9131d55c886a4bdd79557272347ca6f6"

DEPENDS = "aac-module-core aac-module-alexa aac-module-car-control aac-module-local-skill-service"

inherit aac-module devlibsonly