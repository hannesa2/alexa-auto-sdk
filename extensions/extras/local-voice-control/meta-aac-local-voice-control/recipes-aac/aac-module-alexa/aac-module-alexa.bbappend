FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

# Alexa Auto Alexa module modifications for LVC
AAC_PATCHES += "file://0001-LVC-additions-to-module-Alexa.patch"